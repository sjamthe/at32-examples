# Keil uVision project arm_graphic_equalizer_example.uvprojx, settings and files
target arm_graphic_equalizer_example (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F403ZC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F403Zx_HD
  c include: ..\..\..\..\..\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\CM4\CoreSupport;..\..\..\..\CM4\DeviceSupport;..\..\arm_class_marks_example;..\..\..\..\..\..\Project\Templates
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c math_helper.c
  group CMSIS
    ../../../../CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_hd.s
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../CM4/DeviceSupport/: system_at32f4xx.c
  group DOC
    ./: Abstract.txt
